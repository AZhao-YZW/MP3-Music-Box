# Keil uVision project Music_Box.uvproj, settings and files
target Music_Box (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Music_Box +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\code\user;..\code
  link misc: removeunused
  group User
    ./: STARTUP.A51
    ../code/user/: main.c config.h
    ../code/oled/: oled_api.h oled_config.h
    ../code/musicplayer/: mp_config.h
  group Interface
    ../code/menu/: menu.c menu_builder.c menu_settings.h
    ../code/musicplayer/: music_app.c
  group Hardware
    ../code/key/: key.c
    ../code/timer/: timer.c
  group OledLib
    ../code/delay/: delay.c
    ../code/oled/: oled_bmp.c oled_draw.c oled_driver.c oled_font.c oled_misc.c oled_test.c oled_warning.c
  group MusicPlayer
    ../code/musicplayer/: mp_control.c mp_io.c mp_uart_driver.c mp_uart.c
  group Readme
    ../: readme.txt
